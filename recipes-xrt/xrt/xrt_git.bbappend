BRANCH = "2020.1_PU1"
PV = "202010.2.7.0"
SRCREV = "8a4c6eb5012c57423fba468e1af8df53a293dcd5"

PACKAGE_ARCH_versal = "${SOC_FAMILY_ARCH}"
