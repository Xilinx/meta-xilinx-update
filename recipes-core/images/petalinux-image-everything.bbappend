# aarch64 machines has XRT enabled by default.
# Add this to zynq builds as well.
IMAGE_FEATURES_append_zynq = " petalinux-xrt"
